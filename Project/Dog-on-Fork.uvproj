# Keil uVision project Dog-on-Fork.uvproj, settings and files
target DOF (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Dog-on-Fork +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Usb;..\Libraries;..\Libraries\GPIO;..\Libraries\SPI;..\Libraries\EEPROM
  link misc: REMOVEUNUSED
  group Libraries
    ../Libraries/: isr.asm DEBUG.C
    ../Libraries/GPIO/: STC8H_GPIO.c
    ../Libraries/SPI/: STC8G_H_SPI.c
    ../Libraries/EEPROM/: STC8G_H_EEPROM.c
  group Usb
    ../Usb/: usb.c usb_req_class.c usb_req_std.c usb_req_vendor.c
  group User
    ../User/: main.c RgbDrv.c drv_RF24L01.c W25Qxx.c scsi.c Para.c
